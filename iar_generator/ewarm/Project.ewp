# IAR project Project.ewp, settings and files
configuration STM32L412RB (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32L412RB ST STM32L412RB
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IccLang: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.CCIncludePath2: ..\; ..\project\app; ..\project\build_variant; ..\project\firmware\CMSIS\Device\ST\STM32L4xx\Include; ..\project\firmware\CMSIS\Include; ..\project\firmware\STM32L4xx_HAL_Driver\Inc; ..\project\mcu_platforms\stm32\button; ..\project\mcu_platforms\stm32\led; ..\project\mcu_platforms\stm32\system; ..\project\mcu_platforms\stm32\uart; ..\project\middleware\FreeRTOS\Source\CMSIS_RTOS_V2; ..\project\middleware\FreeRTOS\Source\include; ..\project\middleware\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\project\modules\button; ..\project\modules\led; ..\project\modules\system; ..\project\modules\uart; ..\project\modules_configs
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32L412xx; MCU_STM32L412RB
  AARM.ADefines: STM32L412xx; MCU_STM32L412RB
  AARM.AUserIncludes: $PROJ_DIR$; ..\project\middleware\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\project\app
  OBJCOPY.OOCOutputFile: loop_project.hex
  ILINK.IlinkIcfFile: ..\iar\stm32l412xx_flash.icf
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F302R8 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F302xx; MCU_STM32F302R8
  AARM.ADefines: STM32F302xx; MCU_STM32F302R8
