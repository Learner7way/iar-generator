<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>4</fileVersion>
    <configuration>
        <name>STM32L412RB</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>519</archiveVersion>
            <data>
                <version>519</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs/>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>11</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                    <outputDir>STM32L412RB/C-STAT</outputDir>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>2.7.2</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-default" enabled="true"/>
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <configuration>
        <name>STM32F302R8</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>519</archiveVersion>
            <data>
                <version>519</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs/>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>11</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                    <outputDir>STM32F302R8/C-STAT</outputDir>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>2.7.2</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-default" enabled="true"/>
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-default" enabled="true"/>
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group/>
</project>