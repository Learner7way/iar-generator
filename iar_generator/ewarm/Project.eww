<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <fileVersion>1</fileVersion>
    <project>
        <path>$WS_DIR$\project.ewp</path>
    </project>
    <batchBuild/>
</workspace>